# IAR project BaseSystem.ewp, settings and files
configuration BaseSystem STM32 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH; STM32F10X_MD; USE_STDPERIPH_DRIVER; NDEBUG
  ICCARM.CCIncludePath2: ; app\; board\; modules\; CMSIS\Core\CM3\; STM32F10x_StdPeriph_Driver\inc\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  OBJCOPY.OOCOutputFile: BaseSystem.hex
  ILINK.IlinkOutputFile: BaseSystem.out
  ILINK.IlinkKeepSymbols: FuncTable
  ILINK.IlinkIcfFile: config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    app/: cd_class.c crc16.c crc8.c ekz_misc.c int.c loader.c main.c packer.c printf2.c printf2.h putchar2.c spi.c stm32f10x_it.c system.s timer1.c uart1.c usb_dev_desc.c usb_hooks.c var.c
  group CMSIS
    CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_md.s
    CMSIS/Core/CM3/: system_stm32f10x.c
  group modules
    modules/: usb_buffer.c usb_hw.c usb_t9.c
  group StdPeriph_Driver
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
