# IAR project project.ewp, settings and files
configuration Flash Build (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  OBJCOPY.OOCOutputFile: spi-generic.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: .\config\STM32F10x_UserProgram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src
    src/: main.c packer.c sflash.c spi.c startup_user_program.s system.c tick.c
